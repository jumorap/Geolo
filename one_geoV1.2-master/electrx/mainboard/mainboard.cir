* /home/fredy/onegeo-hw/electrx/mainboard/mainboard.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: vie 02 jun 2017 11:58:26 COT

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SHIELD101  UART0_RX_LV UART0_TX_LV PWM2 PWM3 PWM4 PWM5 ? PWM6 PWM7 ? ? ? ? ? D13 UART3_TX_LV UART3_RX_LV UART2_TX_LV UART2_RX_LV UART1_TX_LV UART1_RX_LV SDA SCL X-MIN D23 Y-MIN D25 Z-MIN D27 E0_DIR D29 X-MAX D31 D32 D33 Z-MAX D35 E0_STEP D37 Y-MAX D39 ESTOP D41 E0_EN D43 Z_EN D45 Y_EN D47 X_EN D49 ? ? ? PS-ON +3V3 ? ? ? ? ? ? A4 A5 A6 A7 X_DIR X_STEP Y_DIR Y_STEP Z_DIR Z_STEP AD14 AD15 AREF MOT_GND GNDA GNDA ? /RESET SCL1 SDA1 ? ARDUINO_DUE_SHIELD
M101  LOGO_GMAS
SW101  /RESET MOT_GND RESET
D101  Net-_D101-Pad1_ Net-_D101-Pad2_ LED GRN
R101  FD_5V Net-_D101-Pad1_ 330R
P102  /RESET MOT_GND RESET
Q101  D13 Net-_D101-Pad2_ MOT_GND 2N7002
* Sheet Name: /Power/
P108  MOT_GND /Power/P_IN POWER_IN
F103  /Power/MOT_IN +V_MOTOR FUSE 10A
P107  MOT_GND /Power/MOT_IN MOT_IN
P103  PS-ON PS-ON
P105  +12P MOT_GND 12V-AUX
C102  +12P MOT_GND 100n 35V
C101  +12P MOT_GND 100u 35V
F102  /Power/P_IN +12P FUSE 10A
U3  MOT_GND +12P Net-_C207-Pad1_ LM7812
C207  Net-_C207-Pad1_ MOT_GND 100n 16V
P219  FD_5V MOT_GND EXT_5V
D102  MOT_GND MOT_GND +12P SS10Pxx
* Sheet Name: /Stepper Drivers/
R201  +V_LOGIC MOT_GND 100k
R203  +V_LOGIC MOT_GND 100k
R202  +V_LOGIC MOT_GND 100k
C203  +V_MOTOR MOT_GND 100u 35V
C202  +V_MOTOR MOT_GND 100u 35V
C201  +V_MOTOR MOT_GND 100u 35V
P206  /Stepper Drivers/Z-2B /Stepper Drivers/Z-2A /Stepper Drivers/Z-1A /Stepper Drivers/Z-1B Z-MOT
P205  /Stepper Drivers/Y-2B /Stepper Drivers/Y-2A /Stepper Drivers/Y-1A /Stepper Drivers/Y-1B Y-MOT
P204  /Stepper Drivers/X-2B /Stepper Drivers/X-2A /Stepper Drivers/X-1A /Stepper Drivers/X-1B X-MOT
U203  /Z_EN_BUF +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC Z_STEP Z_DIR MOT_GND +V_LOGIC /Stepper Drivers/Z-1B /Stepper Drivers/Z-1A /Stepper Drivers/Z-2A /Stepper Drivers/Z-2B MOT_GND +V_MOTOR Z
U202  /Y_EN_BUF +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC Y_STEP Y_DIR MOT_GND +V_LOGIC /Stepper Drivers/Y-1B /Stepper Drivers/Y-1A /Stepper Drivers/Y-2A /Stepper Drivers/Y-2B MOT_GND +V_MOTOR Y
U201  /X_EN_BUF +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC X_STEP X_DIR MOT_GND +V_LOGIC /Stepper Drivers/X-1B /Stepper Drivers/X-1A /Stepper Drivers/X-2A /Stepper Drivers/X-2B MOT_GND +V_MOTOR X
* Sheet Name: /Emergency Stop/
U2  Net-_D301-Pad1_ X_EN ? Y_EN ? Z_EN ? E0_EN /E1_EN_BUF MOT_GND D39 /E0_EN_BUF ? /Z_EN_BUF ? /Y_EN_BUF ? /X_EN_BUF Net-_D301-Pad1_ FD_5V 74ACT244
C2  FD_5V MOT_GND 100n
C1  FD_5V MOT_GND 100n
D301  Net-_D301-Pad1_ ESTOP 1N4148
R305  Net-_P302-Pad2_ MOT_GND 4k7
P302  Net-_D301-Pad1_ Net-_P302-Pad2_ ESTOP
R304  +V_LOGIC Net-_D301-Pad1_ 100k
RP23  /X_EN_BUF /Y_EN_BUF /Z_EN_BUF /E0_EN_BUF /E1_EN_BUF FD_5V FD_5V FD_5V FD_5V FD_5V R_Pack05
* Sheet Name: /Stepper Drivers 2/
P212  /Stepper Drivers 2/E1-2B /Stepper Drivers 2/E1-2A /Stepper Drivers 2/E1-1A /Stepper Drivers 2/E1-1B E1-MOT
P217  /Stepper Drivers 2/E0-2B /Stepper Drivers 2/E0-2A /Stepper Drivers 2/E0-1A /Stepper Drivers 2/E0-1B E0-MOT
U205  /E1_EN_BUF +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC D43 D41 MOT_GND +V_LOGIC /Stepper Drivers 2/E1-1B /Stepper Drivers 2/E1-1A /Stepper Drivers 2/E1-2A /Stepper Drivers 2/E1-2B MOT_GND +V_MOTOR Analyzer
U206  /E0_EN_BUF +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC +V_LOGIC E0_STEP E0_DIR MOT_GND +V_LOGIC /Stepper Drivers 2/E0-1B /Stepper Drivers 2/E0-1A /Stepper Drivers 2/E0-2A /Stepper Drivers 2/E0-2B MOT_GND +V_MOTOR Polarizer
C206  +V_MOTOR MOT_GND 100u 35V
C205  +V_MOTOR MOT_GND 100u 35V
R210  +V_LOGIC MOT_GND 100k
R208  +V_LOGIC MOT_GND 100k
* Sheet Name: /Misc Connectors/
P2  +V_LOGIC MOT_GND SDA1 SCL1 I2C-1
R2  +V_LOGIC SDA1 NF
R1  +V_LOGIC SCL1 NF
P1  MOT_GND ? ? UART1_RX_LV UART1_TX_LV ? SERIAL1
P216  MOT_GND ? ? UART0_RX_LV UART0_TX_LV ? SERIAL0
P213  +V_LOGIC MOT_GND D32 D47 D45 D43 D41 D39 D37 D35 D33 D31 D29 D27 D25 D23 UART2_RX_LV UART2_TX_LV AUX-4
P214  +V_LOGIC MOT_GND A4 A5 A6 A7 AD14 AD15 UART3_TX_LV UART3_RX_LV AUX-2
R211  +V_LOGIC SCL NF
R212  +V_LOGIC SDA NF
P211  +V_LOGIC MOT_GND SDA SCL I2C-0
U601  MOT_GND MOT_GND MOT_GND MOT_GND SDA SCL MOT_GND +V_LOGIC 24C512
C601  +V_LOGIC MOT_GND 100n
* Sheet Name: /Endstop Inputs/
C305  +V_LOGIC MOT_GND 100n
U801  +V_LOGIC Z-MAX Net-_P802-Pad2_ Z-MIN Net-_P802-Pad4_ Y-MAX Net-_P802-Pad6_ MOT_GND Net-_P802-Pad8_ Y-MIN Net-_P802-Pad10_ X-MAX Net-_P802-Pad12_ X-MIN 4050_RMC
RP801  ? Net-_P802-Pad6_ Net-_P802-Pad4_ Net-_P802-Pad2_ FD_5V FD_5V FD_5V FD_5V 10k
RP802  Net-_P802-Pad12_ Net-_P802-Pad10_ Net-_P802-Pad8_ ? FD_5V FD_5V FD_5V FD_5V 10k
P802  MOT_GND Net-_P802-Pad2_ MOT_GND Net-_P802-Pad4_ MOT_GND Net-_P802-Pad6_ MOT_GND Net-_P802-Pad8_ MOT_GND Net-_P802-Pad10_ MOT_GND Net-_P802-Pad12_ CONN_6X2
P801  FD_5V FD_5V FD_5V FD_5V FD_5V FD_5V CONN_6
* Sheet Name: /Added by EOST/
DS0  +V_2 +V_2 GND_2 GND_2 +V_3 +V_3 GND_3 GND_3 DC-DC-DSUN
C3  +V_3 GND_3 47u
DC_OUT1  +V_3 GND_3 CONN_2
DC_IN1  +V_2 GND_2 CONN_2
RD29  +V_LOGIC D49 2k
O1  ? D37 GND_3 A1 Net-_O1-Pad5_ +V_3 A1 ? IXDI604
O2  ? PWM6 GND_3 PWM7 O2B +V_3 O2A ? IXDI604
QM1  O2A Net-_C100-Pad1_ +V_3 IRF9530
Dm1  Net-_C100-Pad1_ GND_3 1N5819
M1  Net-_C100-Pad1_ GND_3 CONN_2
C100  Net-_C100-Pad1_ GND_3 220n
QM2  O2B Net-_C200-Pad1_ +V_3 IRF9530
Dm2  Net-_C200-Pad1_ GND_3 1N5819
M2  Net-_C200-Pad1_ GND_3 CONN_2
C200  Net-_C200-Pad1_ GND_3 220n
RD25  D47 +V_LOGIC 2k
RD23  D32 +V_LOGIC 2k
MD0  ? ? +V_LOGIC PWM2 PWM3 PWM4 PWM5 MOT_GND GND_3 +V_3 ? ? DCM22 DCM21 DCM12 DCM11 A4990
JM2  DCM11 DCM12 CONN_01X02
JM3  DCM21 DCM22 CONN_01X02
QG1  Net-_O1-Pad5_ Net-_MSF1-Pad2_ GND_3 IRLZ44N
J11  +V_LOGIC +V_LOGIC MOT_GND MOT_GND D47 D32 CONN_02X03
MSF1  +V_3 Net-_MSF1-Pad2_ CONN_2

.end
